# IAR project stm32f767.ewp, settings and files
configuration stm32f767 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F767ZI ST STM32F767ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F767xx
  ICCARM.CCIncludePath2: ..; ..\lib; ..\lib\CMSIS\Include; ..\lib\CMSIS\Device\ST\STM32F7xx\Include; ..\lib\STM32F7xx_HAL_Driver\Inc; ..\lib\STM32F7xx_HAL_Driver\Inc\Legacy; ..\lib\uip; ..\..\..\..\Source\third_party\uip\uip; ..\..\..\..\Source\third_party\uip\apps\dhcpc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: demoprog_stm32f767.srec
  ILINK.IlinkOutputFile: demoprog_stm32f767.out
  ILINK.IlinkIcfFile: ..\stm32f767xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Prog
    ../: boot.c boot.h header.h led.c led.h main.c net.c net.h shared_params.c shared_params.h startup_stm32f767xx.s timer.c timer.h
  group Prog/lib
    ../lib/: stm32f7xx_hal_conf.h system_stm32f7xx.c
  group Prog/lib/CMSIS
    ../lib/CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
    ../lib/CMSIS/Device/ST/STM32F7xx/Include/: stm32f767xx.h stm32f7xx.h system_stm32f7xx.h
  group Prog/lib/HAL
    ../lib/STM32F7xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
    ../lib/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c
    ../lib/STM32F7xx_HAL_Driver/Inc/: stm32f7xx_hal.h stm32f7xx_hal_cortex.h stm32f7xx_hal_def.h stm32f7xx_hal_dma.h stm32f7xx_hal_dma_ex.h stm32f7xx_hal_eth.h stm32f7xx_hal_flash.h stm32f7xx_hal_flash_ex.h stm32f7xx_hal_gpio.h stm32f7xx_hal_gpio_ex.h stm32f7xx_hal_i2c.h stm32f7xx_hal_i2c_ex.h stm32f7xx_hal_pwr.h stm32f7xx_hal_pwr_ex.h stm32f7xx_hal_rcc.h stm32f7xx_hal_rcc_ex.h stm32f7xx_hal_tim.h stm32f7xx_hal_tim_ex.h stm32f7xx_hal_uart.h stm32f7xx_hal_uart_ex.h
  group Prog/lib/uip
    ../lib/uip/: clock-arch.c clock-arch.h netdev.c netdev.h uip-conf.h
  group Prog/third_party/uip
    ../../../../Source/third_party/uip/uip/: clock.h lc-addrlabels.h lc-switch.h lc.h pt.h uip-fw.c uip-fw.h uip.c uip.h uip_arch.h uip_arp.c uip_arp.h uip_timer.c uip_timer.h uiplib.c uiplib.h uipopt.h
    ../../../../Source/third_party/uip/apps/dhcpc/: dhcpc.c dhcpc.h
