# IAR project xmc1400.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: XMC1404-Q064x0200 Infineon XMC1404-Q064x0200
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: XMC1404_Q064x0200
  ICCARM.CCIncludePath2: ..; ..\..\..\..\Source; ..\..\..\..\Source\ARMCM0_XMC1; ..\..\..\..\Source\ARMCM0_XMC1\IAR; ..\lib; ..\lib\cmsis; ..\lib\xmclib\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: openblt_xmc1400.srec
  ILINK.IlinkOutputFile: openblt_xmc1400.out
  ILINK.IlinkIcfFile: ..\cfg\memory.x
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Boot
    ../: blt_conf.h hooks.c led.c led.h main.c startup_XMC1400.s
  group Boot/lib
    ../lib/: system_XMC1400.c system_XMC1400.h XMC1000_RomFunctionTable.h XMC1400.h
  group Boot/lib/cmsis
    ../lib/cmsis/: cmsis_gcc.h core_cm0.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group Boot/lib/xmclib
    ../lib/xmclib/inc/: xmc1_ccu4_map.h xmc1_ccu8_map.h xmc1_eru_map.h xmc1_flash.h xmc1_gpio.h xmc1_gpio_map.h xmc1_rtc.h xmc1_scu.h xmc1_usic_map.h xmc_acmp.h xmc_bccu.h xmc_can.h xmc_can_map.h xmc_ccu4.h xmc_ccu8.h xmc_common.h xmc_dac.h xmc_device.h xmc_dma.h xmc_dma_map.h xmc_dsd.h xmc_ebu.h xmc_ecat.h xmc_ecat_map.h xmc_eru.h xmc_eth_mac.h xmc_eth_mac_map.h xmc_eth_phy.h xmc_fce.h xmc_flash.h xmc_gpio.h xmc_hrpwm.h xmc_hrpwm_map.h xmc_i2c.h xmc_i2s.h xmc_ledts.h xmc_math.h xmc_pau.h xmc_posif.h xmc_prng.h xmc_rtc.h xmc_scu.h xmc_sdmmc.h xmc_spi.h xmc_uart.h xmc_usbd.h xmc_usbd_regs.h xmc_usbh.h xmc_usic.h xmc_vadc.h xmc_vadc_map.h xmc_wdt.h
    ../lib/xmclib/src/: xmc1_eru.c xmc1_flash.c xmc1_gpio.c xmc1_rtc.c xmc1_scu.c xmc_acmp.c xmc_bccu.c xmc_can.c xmc_ccu4.c xmc_ccu8.c xmc_common.c xmc_dac.c xmc_dma.c xmc_dsd.c xmc_ebu.c xmc_ecat.c xmc_eru.c xmc_eth_mac.c xmc_fce.c xmc_gpio.c xmc_hrpwm.c xmc_i2c.c xmc_i2s.c xmc_ledts.c xmc_math.c xmc_pau.c xmc_posif.c xmc_prng.c xmc_rtc.c xmc_sdmmc.c xmc_spi.c xmc_uart.c xmc_usbd.c xmc_usbh.c xmc_usic.c xmc_vadc.c xmc_wdt.c
  group Source
    ../../../../Source/: asserts.c asserts.h backdoor.c backdoor.h boot.c boot.h can.h com.c com.h cop.c cop.h cpu.h file.c file.h net.c net.h nvm.h plausibility.h rs232.h timer.h usb.h xcp.c xcp.h
  group Source/ARMCM0_XMC1
    ../../../../Source/ARMCM0_XMC1/: can.c cpu.c flash.c flash.h nvm.c rs232.c timer.c types.h
  group Source/ARMCM0_XMC1/IAR
    ../../../../Source/ARMCM0_XMC1/IAR/: cpu_comp.c
