# IAR project lm3s6965.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S6965 TexasInstruments LM3S6965
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: ewarm; DEBUG
  ICCARM.CCIncludePath2: ..; ..\lib; ..\lib\inc; ..\lib\driverlib; ..\lib\uip; ..\..\..\..\Source\third_party\uip\uip; ..\..\..\..\Source\third_party\uip\apps\dhcpc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: demoprog_ek_lm3s6965.srec
  ILINK.IlinkOutputFile: demoprog_ek_lm3s6965.out
  ILINK.IlinkIcfFile: ..\memory.x
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group Prog
    ../: boot.c boot.h cstart.s header.h led.c led.h main.c net.c net.h shared_params.c shared_params.h time.c time.h vectors.c
  group Prog/lib/driverlib
    ../lib/driverlib/: adc.c adc.h comp.c comp.h cpu.c cpu.h debug.h epi.c epi.h ethernet.c ethernet.h flash.c flash.h gpio.c gpio.h hibernate.c hibernate.h i2c.c i2c.h i2s.c i2s.h interrupt.c interrupt.h mpu.c mpu.h pin_map.h pwm.c pwm.h qei.c qei.h rom.h rom_map.h ssi.c ssi.h sysctl.c sysctl.h systick.c systick.h timer.c timer.h uart.c uart.h udma.c udma.h usb.c usb.h watchdog.c watchdog.h
  group Prog/lib/inc
    ../lib/inc/: asmdefs.h hw_adc.h hw_comp.h hw_epi.h hw_ethernet.h hw_flash.h hw_gpio.h hw_hibernate.h hw_i2c.h hw_i2s.h hw_ints.h hw_memmap.h hw_nvic.h hw_pwm.h hw_qei.h hw_ssi.h hw_sysctl.h hw_timer.h hw_types.h hw_uart.h hw_udma.h hw_usb.h hw_watchdog.h lm3s6965.h
  group Prog/lib/uip
    ../lib/uip/: clock-arch.c clock-arch.h netdev.c netdev.h uip-conf.h
  group Prog/third_party/uip
    ../../../../Source/third_party/uip/uip/: clock.h lc-addrlabels.h lc-switch.h lc.h pt.h uip-fw.c uip-fw.h uip-neighbor.h uip-split.h uip.c uip.h uip_arch.h uip_arp.c uip_arp.h uip_timer.c uip_timer.h uiplib.c uiplib.h uipopt.h
    ../../../../Source/third_party/uip/apps/dhcpc/: dhcpc.c dhcpc.h
