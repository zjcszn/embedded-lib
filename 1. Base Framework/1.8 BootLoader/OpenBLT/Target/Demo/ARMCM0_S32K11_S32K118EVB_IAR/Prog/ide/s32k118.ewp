# IAR project s32k118.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: S32K118 NXP S32K118
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CPU_S32K118
  ICCARM.CCIncludePath2: ..; ..\lib
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: START_FROM_FLASH
  OBJCOPY.OOCOutputFile: demoprog_s32k118.srec
  ILINK.IlinkOutputFile: demoprog_s32k118.out
  ILINK.IlinkIcfFile: ..\S32K118_25_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  group Prog
    ../: boot.c boot.h header.h led.c led.h main.c startup_S32K118.s timer.c timer.h
  group Prog/lib
    ../lib/: devassert.h device_registers.h s32_core_cm0.h S32K118.h S32K118_features.h startup.c startup.h system_S32K118.c system_S32K118.h
