# IAR project stm32f091.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F091RC ST STM32F091RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: STM32F091xC; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\lib; ..\lib\CMSIS\Device\ST\STM32F0xx\Include; ..\lib\CMSIS\Include; ..\lib\STM32F0xx_HAL_Driver\Inc; ..\lib\STM32F0xx_HAL_Driver\Inc\Legacy; ..\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: demoprog_stm32f091.srec
  ILINK.IlinkOutputFile: demoprog_stm32f091.out
  ILINK.IlinkIcfFile: ..\stm32f091_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Prog
    ../: boot.c boot.h header.h led.c led.h main.c startup_stm32f091.s timer.c timer.h
  group Prog/lib
    ../lib/: stm32f0xx_hal_conf.h system_stm32f0xx.c
  group Prog/lib/CMSIS
    ../lib/CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h
    ../lib/CMSIS/Device/ST/STM32F0xx/Include/: stm32f091xc.h stm32f0xx.h system_stm32f0xx.h
  group Prog/lib/HAL
    ../lib/STM32F0xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
    ../lib/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_can.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c
    ../lib/STM32F0xx_HAL_Driver/Inc/: stm32f0xx_hal.h stm32f0xx_hal_can.h stm32f0xx_hal_cortex.h stm32f0xx_hal_def.h stm32f0xx_hal_dma.h stm32f0xx_hal_dma_ex.h stm32f0xx_hal_flash.h stm32f0xx_hal_flash_ex.h stm32f0xx_hal_gpio.h stm32f0xx_hal_gpio_ex.h stm32f0xx_hal_i2c.h stm32f0xx_hal_i2c_ex.h stm32f0xx_hal_pwr.h stm32f0xx_hal_pwr_ex.h stm32f0xx_hal_rcc.h stm32f0xx_hal_rcc_ex.h stm32f0xx_hal_tim.h stm32f0xx_hal_tim_ex.h stm32f0xx_hal_uart.h stm32f0xx_hal_uart_ex.h
