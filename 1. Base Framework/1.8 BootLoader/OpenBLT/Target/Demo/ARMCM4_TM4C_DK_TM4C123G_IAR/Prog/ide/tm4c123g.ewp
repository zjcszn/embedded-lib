# IAR project tm4c123g.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PGE TexasInstruments TM4C123GH6PGE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PGE; TARGET_IS_BLIZZARD_RA1; DEBUG
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\lib; ..\lib\inc; ..\lib\driverlib
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..; ..\..\..\..; ..\..\..\..\third_party
  OBJCOPY.OOCOutputFile: demoprog_dk_tm4c123g.srec
  ILINK.IlinkOutputFile: demoprog_dk_tm4c123g.out
  ILINK.IlinkIcfFile: ..\memory.x
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: time.c time.h
  group Prog
    ../: boot.c boot.h cstart.s header.h led.c led.h main.c vectors.c
  group Prog/lib/driverlib
    ../lib/driverlib/: adc.c adc.h can.c can.h comp.c comp.h cpu.c cpu.h debug.h eeprom.c eeprom.h flash.c flash.h fpu.c fpu.h gpio.c gpio.h hibernate.c hibernate.h i2c.c i2c.h interrupt.c interrupt.h mpu.c mpu.h pin_map.h pwm.c pwm.h qei.c qei.h rom.h rom_map.h rtos_bindings.h ssi.c ssi.h sw_crc.c sw_crc.h sysctl.c sysctl.h sysexc.c sysexc.h systick.c systick.h timer.c timer.h uart.c uart.h udma.c udma.h usb.c usb.h watchdog.c watchdog.h
  group Prog/lib/inc
    ../lib/inc/: asmdefs.h hw_adc.h hw_can.h hw_comp.h hw_eeprom.h hw_fan.h hw_flash.h hw_gpio.h hw_hibernate.h hw_i2c.h hw_ints.h hw_lpc.h hw_memmap.h hw_nvic.h hw_peci.h hw_pwm.h hw_qei.h hw_ssi.h hw_sysctl.h hw_sysexc.h hw_timer.h hw_types.h hw_uart.h hw_udma.h hw_usb.h hw_watchdog.h tm4c123gh6pge.h
