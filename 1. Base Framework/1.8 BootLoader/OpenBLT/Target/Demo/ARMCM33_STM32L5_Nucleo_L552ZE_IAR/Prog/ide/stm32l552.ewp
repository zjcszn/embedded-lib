# IAR project stm32l552.ewp, settings and files
configuration stm32l552 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L552ZE ST STM32L552ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L552xx
  ICCARM.CCIncludePath2: ..; ..\lib; ..\lib\CMSIS\Include; ..\lib\CMSIS\Device\ST\STM32L5xx\Include; ..\lib\STM32L5xx_HAL_Driver\Inc; ..\lib\STM32L5xx_HAL_Driver\Inc\Legacy
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: demoprog_stm32l552.srec
  ILINK.IlinkOutputFile: demoprog_stm32l552.out
  ILINK.IlinkIcfFile: ..\stm32l552xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Prog
    ../: boot.c boot.h header.h led.c led.h main.c startup_stm32l552xx.s timer.c timer.h
  group Prog/lib
    ../lib/: stm32l5xx_hal_conf.h system_stm32l5xx.c
  group Prog/lib/CMSIS
    ../lib/CMSIS/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm33.h tz_context.h
    ../lib/CMSIS/Device/ST/STM32L5xx/Include/: stm32l552xx.h stm32l5xx.h system_stm32l5xx.h
  group Prog/lib/HAL
    ../lib/STM32L5xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
    ../lib/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal.c stm32l5xx_hal_cortex.c stm32l5xx_hal_dma.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_exti.c stm32l5xx_hal_fdcan.c stm32l5xx_hal_flash.c stm32l5xx_hal_flash_ex.c stm32l5xx_hal_flash_ramfunc.c stm32l5xx_hal_gpio.c stm32l5xx_hal_i2c.c stm32l5xx_hal_i2c_ex.c stm32l5xx_hal_icache.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_tim.c stm32l5xx_hal_tim_ex.c stm32l5xx_hal_uart.c stm32l5xx_hal_uart_ex.c
    ../lib/STM32L5xx_HAL_Driver/Inc/: stm32l5xx_hal.h stm32l5xx_hal_cortex.h stm32l5xx_hal_def.h stm32l5xx_hal_dma.h stm32l5xx_hal_dma_ex.h stm32l5xx_hal_exti.h stm32l5xx_hal_fdcan.h stm32l5xx_hal_flash.h stm32l5xx_hal_flash_ex.h stm32l5xx_hal_flash_ramfunc.h stm32l5xx_hal_gpio.h stm32l5xx_hal_gpio_ex.h stm32l5xx_hal_i2c.h stm32l5xx_hal_i2c_ex.h stm32l5xx_hal_icache.h stm32l5xx_hal_pwr.h stm32l5xx_hal_pwr_ex.h stm32l5xx_hal_rcc.h stm32l5xx_hal_rcc_ex.h stm32l5xx_hal_tim.h stm32l5xx_hal_tim_ex.h stm32l5xx_hal_uart.h stm32l5xx_hal_uart_ex.h
